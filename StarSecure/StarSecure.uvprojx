# Keil uVision project StarSecure.uvprojx, settings and files
target armstar_secure (6160000::V6.16::ARMCLANG)
  device: STAR_SE ArmChina
  pack: ArmChina.STAR.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: StarSecure
  AfterMake: fromelf --text -a -c  --output=#L.txt #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: COMPILER_VERSION=__VERSION__ COMPILER_FLAGS=\"-Omax\"
  c include: D:\Keil_v536\ARM\ArmChina\STAR\1.4.0\CMSIS\Core\Include;.\driver\uart;..\platform;..\platform\bk7236_fpga;..\config;.\driver;.\driver\scb;.\driver\mpu;.\driver\sau;.\cortex_trace\cm_backtrace;.\secure_field_verify;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\ARMv8M\secure\macros;..\FreeRTOS\Config
  asm include: ..\config
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\Device\STAR_SE\STAR_ac6.sct
  link misc: --import-cmse-lib-out="..\StarSecure\Output\Objects\CM33_s_CMSE_Lib.o"
  group user
    ./Source/: core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h secure_util.c secure_tft.c sec_main.c
  group driver
    ./driver/uart/: secure_uart.c
    ./driver/: bk_secure_driver.c
    ./driver/mpu/: mpu.c
    ./driver/scb/: scb.h
    ./driver/sau/: sau.h
  group cm_backtrace
    ./cortex_trace/cm_backtrace/: cm_backtrace.c
    ./cortex_trace/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group test
    ./test/: ro_file.c xn_file.c xo_file.c
    ./secure_field_verify/: sfv_s.c
  group secure_context
    ../FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_context.c secure_context_port.c secure_context.h secure_port_macros.h
  group secure_init
    ../FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_init.c secure_init.h
  group secure_heap
    ../FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_heap.c secure_heap.h
  group nsc_function
    ../FreeRTOS/Demo/Common/ARMv8M/tz_demo/: nsc_functions.c nsc_functions.h
software components: CMSIS:CORE 5.5.0, CMSIS Driver:USART:STAR USART 1.1.0, Device:Startup 1.1.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
