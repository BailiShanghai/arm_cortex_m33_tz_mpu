# Keil uVision project StarNoSecure.uvprojx, settings and files
target armstar_non_secure (6160000::V6.16::ARMCLANG)
  device: STAR_SE ArmChina
  pack: ArmChina.STAR.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: StarNoSecure +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c  --output=#L.txt #L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: __EN_ICACHE=1 __EN_DCACHE=1  SEED_METHOD=SEED_ARG COMPILER_VERSION=__VERSION__ COMPILER_FLAGS=\"-Omax\"
  c include: D:\Keil_v536\ARM\ArmChina\STAR\1.3.0\CMSIS\Core\Include;..\config;..\platform;..\platform\bk7236_fpga;.\driver;.\driver\uart;..\FreeRTOS\Source\include;..\FreeRTOS\Config;..\FreeRTOS\Source\portable\GCC\ARM_CM33\non_secure;..\FreeRTOS\Source\portable\GCC\ARM_CM33\secure;..\FreeRTOS\Demo\Common\ARMv8M\mpu_demo;..\FreeRTOS\Demo\Common\ARMv8M\tz_demo;.\test\os\os_thread
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\ns_freertos.sct
  link misc: --datacompressor=off
  group User
    ./Source/: core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h nosecure_util.c nosecure_tft.c non_sec_main.c
  group driver
    ./driver/: bk_no_secure_driver.c
    ./driver/uart/: no_secure_uart.c
  group CMSE lib
    ../StarSecure/Output/Objects/: CM33_s_CMSE_Lib.o
  group freertos
    ../FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/portable/ARMv8M/non_secure/: portasm.h
    ../FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure/: port.c portasm.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/Common/: mpu_wrappers.c
  group config
    ../FreeRTOS/Config/: FreeRTOSConfig.h
  group demo
    ../FreeRTOS/Demo/Common/ARMv8M/mpu_demo/: mpu_demo.c
    ../FreeRTOS/Demo/Common/ARMv8M/tz_demo/: tz_demo.c
  group entry
    ./driver/startup/: startup_ARMCM33.S
  group test
    ./test/os/os_thread/: os_thread.c
software components: CMSIS:CORE 5.5.0, CMSIS Driver:USART:STAR USART 1.0.0, Device:Startup 1.1.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
